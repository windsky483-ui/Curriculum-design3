# Keil uVision project MPU6050_Test.uvprojx, settings and files
target MPU6050_Test (6220000::V6.22::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: MPU6050_Test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,HSE_VALUE=8000000
  c include: .\Libraries\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c reco.c
  group Device
    ./Libraries/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
    ./Libraries/Device/ST/STM32F4xx/Source/ARM/: startup_stm32f407xx.s
